# Autodesk Inventor assembly: Test1
## iProperties
Created: 2007-03
Part Number: Test1
Document SubType Name: Assembly
Designer: Sascha Fleischer
Author: Sascha Fleischer
