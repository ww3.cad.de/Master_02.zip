# Autodesk Inventor part: Test1_SKL
## iProperties
Created: 2007-03
Part Number: Test1_SKL
Document SubType Name: Modeling
Designer: Sascha Fleischer
Author: Sascha Fleischer
